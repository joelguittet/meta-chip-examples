DESCRIPTION = "CHIP image 1-Wire example"
LICENSE = "MIT"

require recipes-core/images/chip-image-minimal.bb

IMAGE_INSTALL += " \
"
